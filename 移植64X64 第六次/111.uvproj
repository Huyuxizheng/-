# Keil uVision project 111.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 111 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: 2048HZAPI.c 2048JDAPI.c 2048JGT.c 2048SXAPI.c 2048XIZTAPI.c 主程序.c 2048GJAPI.c 2048SJK.c 2048KJAPI.c 2048HBAPP.c TDXRAPP.c
